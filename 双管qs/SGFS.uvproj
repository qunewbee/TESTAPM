# Keil uVision project SGFS.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F040 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: SGFS +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\双管qs
  group Source Group 1
    ./: STARTUP.A51 main.c uart.c
